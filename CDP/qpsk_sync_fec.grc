options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: mpsk_stage6
    output_language: python
    title: mpsk_stage6.grc
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: frame_size*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '58'
  states: {}
- name: enc_ccsds
  id: variable_ccsds_encoder_def
  parameters:
    framebits: frame_size*8
    mode: fec.CC_TAILBITING
    ndim: '0'
    state_start: '0'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Set Bandwidth
    value: '0.5'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 433e6
    step: 100e3
    stop: 533e6
    value: 433e6
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF gain
    start: '0'
    step: '1'
    stop: '50'
    value: '40'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.6'
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: '60'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109,79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: rf_gain_0
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: rf_gain_sink
  id: variable_qtgui_range
  parameters:
    label: RF gain sink
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rx_freq_
  id: variable
  parameters:
    comment: Set rx frequency
    value: 433e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_blade
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples Per Symbol
    value: '4'
  states: {}
- name: sps_0
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: tx_freq
  id: variable
  parameters:
    comment: Set tx frequency
    value: 600e6
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: bladeRF_sink_0
  id: bladeRF_sink
  parameters:
    bias_tee0: 'True'
    bias_tee1: 'False'
    bw: '200000'
    comment: |-
      Transmitter block related to bladeRF, 
      if you are using USRP, need to replace this block
    dac: '10000'
    dc_calibration: LPF_TUNING
    device_id: '1'
    fpga_image: ''
    fpga_reload: 'False'
    freq: rx_freq_
    gain0: '0'
    gain1: '10'
    if_gain0: '0'
    if_gain1: '20'
    in_clk: ONBOARD
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_rate: 750e3
    sampling: internal
    show_pmic: 'False'
    smb: '0'
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'True'
    use_ref_clk: 'False'
    verbosity: debug
    xb200: auto
  states: {state: disabled}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'True'
    bias_tee1: 'False'
    bw: '200000'
    comment: |-
      Receiver block
      if you are using 
      other receivers
      need to replace
      the block
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: '1'
    fpga_image: ''
    fpga_reload: 'False'
    freq: rx_freq_
    gain0: '10'
    gain1: '10'
    gain_mode0: 'True'
    gain_mode1: 'False'
    if_gain0: '10'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_rate: 750e3
    sampling: internal
    show_pmic: 'False'
    smb: '0'
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: info
    xb200: auto
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    comment: prepare to match time sink
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\mnavi\OneDrive\Documents\gnu radio\synced.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\mnavi\OneDrive\Documents\gnu radio\rximage.jpg
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\mnavi\OneDrive\Documents\gnu radio\sink1.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\mnavi\OneDrive\Documents\gnu radio\sink_trans.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\mnavi\OneDrive\Documents\gnu radio\University_of_Moratuwa_logo (1).png
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\mnavi\OneDrive\Documents\gnu radio\syncword.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '4'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Simulated channel
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {state: disabled}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    comment: |-
      Multipath compensation 
      (CMA Equalizer)
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    comment: Timing  synchronization
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: fec_extended_decoder_1
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_cc
    puncpat: puncpat
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_2
  id: fec_extended_encoder
  parameters:
    encoder_list: enc_ccsds
    puncpat: puncpat
    threadtype: capillary
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame size
    type: intx
    value: '30'
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The CMA equalizer has been
      replaced by a Linear Equalizer
      and an Adaptive Algorithm for
      version 3.9
    note: CMA equalizer replaced
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: https://wiki.gnuradio.org/index.php?title=Guided_Tutorial_PSK_Demodulation
    note: Tutorial url
  states: {}
- name: note_1
  id: note
  parameters:
    comment: stream of bits generation
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladeRf=0,biastee=1
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: puncpat
  id: parameter
  parameters:
    type: str
    value: '11'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency Spectrum of Tx
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'received@1: 0,0,1,1'
    label1: Symbols
    name: ''
    size: '500'
    srate: samp_rate
    type: float
    ymax: '4'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    label1: Rx Bits
    label2: Tx Bits
    name: ''
    nconnections: '2'
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation
    label1: Symbols
    num_tabs: '2'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: rx_freq_
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 1e6
    sync: sync
    type: fc32
  states: {state: disabled}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: packet_size
    sync: '"00011010110011111111110000011101"'
    threshold: '4'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bytes
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Sync Bytes
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Bytes
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Sync Bytes
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [bladeRF_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_delay_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', fec_extended_decoder_1, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0_1, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', virtual_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_file_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_throttle_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_throttle_0_1, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', fec_extended_encoder_2, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [channels_channel_model_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', bladeRF_sink_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_constellation_modulator_0, '0', channels_channel_model_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [fec_extended_decoder_1, '0', blocks_pack_k_bits_bb_0, '0']
- [fec_extended_encoder_2, '0', digital_map_bb_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0_0_0_0, '0']
- [rtlsdr_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [satellites_sync_to_pdu_packed_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [virtual_source_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_0_0_0, '0', blocks_tagged_stream_mux_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
