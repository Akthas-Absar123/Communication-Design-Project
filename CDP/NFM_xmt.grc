options:
  parameters:
    author: mnavi
    generate_options: qt_gui
    id: NFM_xmt
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: if_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: pl_freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[]'
    num_opts: '0'
    options: '[0, 67, 71.9]'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.150'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}

connections:
- [analog_nbfm_tx_0, '0', virtual_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [audio_source_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
