options:
  parameters:
    author: mnavi
    generate_options: qt_gui
    id: mpsk_stage6
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '0.100'
    value: '0.01'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.025'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    label: Phase:Bandwidth
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2,3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,samp_rate,samp_rate/sps,excess_bw,11*sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '0.2'
    value: '0.0628'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0005'
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    label0: channel
    label1: reciever
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: '4'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: timing_loop_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '2'
    sps: '4004'
    taps: rrc_taps
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [blocks_char_to_float_0, '0', blocks_delay_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_1_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_1_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_1_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0_1, '0']
- [digital_linear_equalizer_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
